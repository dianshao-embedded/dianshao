# build file system based on core-image-minimal
require recipes-core/images/core-image-minimal.bb